# Keil uVision project proj.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103TB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: proj
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARDUINO=111
  c misc: --gnu
  c include: ..\ArduinoAPI;..\Core;..\USER;..\..\..\Libraries
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.cpp
  group Libraries
    ../../../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../../../Libraries/VFD_GP1211AI/: VFD_GP1211AI.cpp
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c HardwareSerial.cpp itoa.c Print.cpp WString.cpp Wire.cpp WireBase.cpp WMath.cpp SPI.cpp Stream.cpp Tone.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c timer.c
    ../CORE/: delay.c
  group README
    ../: README.md
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
